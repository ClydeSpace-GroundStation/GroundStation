<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>minsize</key><value>50</value></param>
<param><key>maxsize</key><value>50</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>tnc_ax25_framer</key>
<param><key>id</key><value>tnc_ax25_framer_0</value></param>
<param><key>mycall</key><value>KI4MTT</value></param>
<param><key>destcall</key><value>KI4MTS</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>tnc_hdlc_framer</key>
<param><key>id</key><value>tnc_hdlc_framer_0</value></param>
<param><key>preamble_length</key><value>50</value></param>
<param><key>postamble_length</key><value>7</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>use_scrambler</key><value>False</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>tnc_hdlc_deframer</key>
<param><key>id</key><value>tnc_hdlc_deframer_0</value></param>
</block>
<block>
<key>tnc_ax25_deframer</key>
<param><key>id</key><value>tnc_ax25_deframer_0</value></param>
<param><key>mycall</key><value>KI4MTT</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>tnc_ax25_framer_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>tnc_ax25_deframer_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>tnc_ax25_framer_0</source_block_id><sink_block_id>tnc_hdlc_framer_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>tnc_hdlc_framer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>tnc_hdlc_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tnc_hdlc_deframer_0</source_block_id><sink_block_id>tnc_ax25_deframer_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
