<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ccsds_decode</value></param>
<param><key>author</key><value>Thomas Parry</value></param>
<param><key>category</key><value>Clyde Space</value></param>
<param><key>description</key><value>Block to perform the channel decoding as defined in the CCSDS channel coding standard</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>CCSDS Channel Decoding</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>dec_cc</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>k</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>frame_size</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_size</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[79, 109]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>puncpat</value></param>
<param><key>value</key><value>'11'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>ais_invert</key>
<param><key>id</key><value>ais_invert_0</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>ccsds_asm_deframer_pdu</key>
<param><key>id</key><value>ccsds_asm_deframer_pdu_0</value></param>
<param><key>block_size</key><value>255</value></param>
<param><key>distance</key><value>hamming_distance</value></param>
<param><key>interleave</key><value>interleave</value></param>
<param><key>randomise</key><value>1</value></param>
</block>
<block>
<key>ccsds_rs_decode_pdu</key>
<param><key>id</key><value>ccsds_rs_decode_pdu_0</value></param>
<param><key>interleave</key><value>interleave</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0</value></param>
<param><key>map</key><value>[-1, 1]</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0</value></param>
<param><key>decoder_list</key><value>dec_cc</value></param>
<param><key>puncpat</key><value>puncpat</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hamming_distance</value></param>
<param><key>label</key><value>Hamming Distance</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interleave</value></param>
<param><key>label</key><value>Interleave Depth</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>ais_invert_0</source_block_id><sink_block_id>digital_map_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>fec_extended_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_asm_deframer_pdu_0</source_block_id><sink_block_id>ccsds_rs_decode_pdu_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>ccsds_rs_decode_pdu_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>pdu_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_map_bb_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>ccsds_asm_deframer_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ais_invert_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
