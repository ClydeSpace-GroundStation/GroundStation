<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ax25_encode_heir</value></param>
<param><key>author</key><value>Thomas Parry</value></param>
<param><key>category</key><value>Clyde Space</value></param>
<param><key>description</key><value>Receive PDUs and output tagged streams ready for line coding</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>AX.25 Encoding Heir Block</value></param>
</block>
<block>
<key>ax25_ax25_encoder</key>
<param><key>id</key><value>ax25_ax25_encoder_0</value></param>
<param><key>dest_addr</key><value>destination_callsign</value></param>
<param><key>dest_ssid</key><value>destination_ssid</value></param>
<param><key>src_addr</key><value>source_callsign</value></param>
<param><key>src_ssid</key><value>source_ssid</value></param>
</block>
<block>
<key>ax25_pdu_prepend_append</key>
<param><key>id</key><value>ax25_pdu_prepend_append_0</value></param>
<param><key>append_length</key><value>post_sync_quantity</value></param>
<param><key>fill_byte</key><value>sync_value</value></param>
<param><key>prepend_length</key><value>pre_sync_quantity</value></param>
</block>
<block>
<key>ax25_pdu_prepend_append</key>
<param><key>id</key><value>ax25_pdu_prepend_append_0_0</value></param>
<param><key>append_length</key><value>post_flag_quantity</value></param>
<param><key>fill_byte</key><value>0x7e</value></param>
<param><key>prepend_length</key><value>pre_flag_quantity</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>destination_callsign</value></param>
<param><key>label</key><value>Destination Callsign</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"SPACE"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>destination_ssid</value></param>
<param><key>label</key><value>Destination SSID</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>pdus in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>post_flag_quantity</value></param>
<param><key>label</key><value>Post-Flag Quantity </value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>post_sync_quantity</value></param>
<param><key>label</key><value>Post-Sync Quantity </value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_flag_quantity</value></param>
<param><key>label</key><value>Pre-Flag Quantity </value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_sync_quantity</value></param>
<param><key>label</key><value>Pre-Sync Quantity </value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>source_callsign</value></param>
<param><key>label</key><value>Source Callsign</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"EARTH"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>source_ssid</value></param>
<param><key>label</key><value>Source SSID</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_value</value></param>
<param><key>label</key><value>Sync Value</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>85</value></param>
</block>
<connection><source_block_id>ax25_ax25_encoder_0</source_block_id><sink_block_id>ax25_pdu_prepend_append_0_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>ax25_pdu_prepend_append_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ax25_pdu_prepend_append_0_0</source_block_id><sink_block_id>ax25_pdu_prepend_append_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ax25_ax25_encoder_0</sink_block_id><source_key>out</source_key><sink_key>pdu_in</sink_key></connection>
</flow_graph>
