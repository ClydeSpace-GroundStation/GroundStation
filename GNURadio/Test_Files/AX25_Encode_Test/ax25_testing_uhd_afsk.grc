<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>afsk_centre_freq</value></param>
<param><key>value</key><value>afsk_mark + afsk_deviation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>afsk_deviation</value></param>
<param><key>value</key><value>(afsk_space - afsk_mark)/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>afsk_mark</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>afsk_sensitivity</value></param>
<param><key>value</key><value>2*3.14156926*500/(samp_rate/interpolation)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>afsk_space</value></param>
<param><key>value</key><value>2200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bitrate</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interpolation</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_bw</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_freq</value></param>
<param><key>value</key><value>145e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>614.4e3</value></param>
</block>
<block>
<key>afsk_ax25decode</key>
<param><key>id</key><value>afsk_ax25decode_0</value></param>
<param><key>debug_level</key><value>4</value></param>
<param><key>sample_rate</key><value>int(samp_rate)</value></param>
</block>
<block>
<key>analog_cpfsk_bc</key>
<param><key>id</key><value>analog_cpfsk_bc_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>k</key><value>afsk_sensitivity</value></param>
<param><key>samples_per_symbol</key><value>int(samp_rate/interpolation/bitrate)</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0</value></param>
<param><key>audio_rate</key><value>int(samp_rate/interpolation)</value></param>
<param><key>max_dev</key><value>5e3</value></param>
<param><key>quad_rate</key><value>int(samp_rate/interpolation)</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>afsk_centre_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate/interpolation</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>ax25_ax25_encoder</key>
<param><key>id</key><value>ax25_ax25_encoder_0</value></param>
<param><key>dest_addr</key><value>"SPACE "</value></param>
<param><key>dest_ssid</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>src_addr</key><value>"EARTH "</value></param>
<param><key>src_ssid</key><value>0</value></param>
</block>
<block>
<key>ax25_nrzi_encoder</key>
<param><key>id</key><value>ax25_nrzi_encoder_0</value></param>
</block>
<block>
<key>ax25_pdu_prepend_append</key>
<param><key>id</key><value>ax25_pdu_prepend_append_0</value></param>
<param><key>append_length</key><value>256</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fill_byte</key><value>0x55</value></param>
<param><key>prepend_length</key><value>512</value></param>
</block>
<block>
<key>ax25_pdu_prepend_append</key>
<param><key>id</key><value>ax25_pdu_prepend_append_0_0</value></param>
<param><key>append_length</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fill_byte</key><value>0x7e</value></param>
<param><key>prepend_length</key><value>40</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-1.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>100</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length_modulo</key><value>1</value></param>
<param><key>maxsize</key><value>256</value></param>
<param><key>minsize</key><value>32</value></param>
</block>
<block>
<key>es_source</key>
<param><key>id</key><value>es_source_0</value></param>
<param><key>eb</key><value>balk</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>nthreads</key><value>1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_streams</key><value>1</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>fbw</key><value>0.125</value></param>
<param><key>interp</key><value>16</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>show_text</key>
<param><key>id</key><value>show_text_0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>rf_bw</value></param>
<param><key>center_freq0</key><value>rf_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>30.72e6</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
<param><key>otw</key><value>sc12</value></param>
</block>
<connection><source_block_id>afsk_ax25decode_0</source_block_id><sink_block_id>show_text_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_cpfsk_bc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ax25_ax25_encoder_0</source_block_id><sink_block_id>ax25_pdu_prepend_append_0_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>ax25_nrzi_encoder_0</source_block_id><sink_block_id>analog_cpfsk_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ax25_nrzi_encoder_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ax25_pdu_prepend_append_0</source_block_id><sink_block_id>es_source_0</sink_block_id><source_key>pdu_out</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>ax25_pdu_prepend_append_0_0</source_block_id><sink_block_id>ax25_pdu_prepend_append_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>analog_nbfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0</source_block_id><sink_block_id>afsk_ax25decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>ax25_nrzi_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>ax25_ax25_encoder_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>fosphor_qt_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
