<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3200</value></param>
</block>
<block>
<key>ax25_ax25_encoder</key>
<param><key>id</key><value>ax25_ax25_encoder_0</value></param>
<param><key>dest_addr</key><value>"SPACE "</value></param>
<param><key>dest_ssid</key><value>0</value></param>
<param><key>src_addr</key><value>"EARTH "</value></param>
<param><key>src_ssid</key><value>0</value></param>
</block>
<block>
<key>ax25_pdu_prepend_append</key>
<param><key>id</key><value>ax25_pdu_prepend_append_0</value></param>
<param><key>append_length</key><value>8</value></param>
<param><key>fill_byte</key><value>0x00</value></param>
<param><key>prepend_length</key><value>8</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_source</key>
<param><key>id</key><value>blocks_message_source_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>2000</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>1</value></param>
<param><key>maxsize</key><value>256</value></param>
<param><key>minsize</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>bruninga_hdlc_to_ax25</key>
<param><key>id</key><value>bruninga_hdlc_to_ax25_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_hdlc_deframer_bp</key>
<param><key>id</key><value>digital_hdlc_deframer_bp_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>500</value></param>
<param><key>min</key><value>32</value></param>
</block>
<block>
<key>ec_ax25_decoder_b</key>
<param><key>id</key><value>ec_ax25_decoder_b_0</value></param>
<param><key>filename</key><value></value></param>
<param><key>print_to_file</key><value>0</value></param>
<param><key>printing</key><value>True</value></param>
</block>
<block>
<key>show_text</key>
<param><key>id</key><value>show_text_0</value></param>
</block>
<connection><source_block_id>ax25_ax25_encoder_0</source_block_id><sink_block_id>ax25_pdu_prepend_append_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>ax25_ax25_encoder_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdu_out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>ax25_pdu_prepend_append_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_message_source_0</source_block_id><sink_block_id>show_text_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>ax25_ax25_encoder_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>digital_hdlc_deframer_bp_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>ec_ax25_decoder_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_hdlc_deframer_bp_0</source_block_id><sink_block_id>bruninga_hdlc_to_ax25_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
